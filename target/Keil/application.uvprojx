# Keil uVision project application.uvprojx, settings and files
target LPCXpresso54608 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: application +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, USE_RTOS=1, PRINTF_ADVANCED_ENABLE=1, FSL_RTOS_FREE_RTOS, USE_FREERTOS_8
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\..\platform\os;..\bsp\SDK\Keil\rtos\freertos_9.0.0\Source\portable\RVDS\ARM_CM4F;..\bsp\SDK\Keil\rtos\freertos_9.0.0\Source\include;..\bsp\SDK\Keil\rtos\freertos_9.0.0\Source;..\bsp\SDK\Keil\CMSIS\Include;..\bsp\SDK\Keil\devices;..\bsp\SDK\Keil\devices\LPC54608;..\bsp\SDK\Keil\devices\LPC54608\drivers;..\bsp\SDK\Keil\devices\LPC54608\utilities;../../touchgfx/framework/include;..\..\generated\fonts\include;..\..\generated\images\include;..\..\generated\texts\include;..\..\generated\gui_generated\include;..\..\gui\include;..\bsp\include;..\bsp\board
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\LPC54608J512_flash.scf
  group TouchGFXPort
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: FT5336GQQTouchController.cpp
    ../bsp/source/platform/hal/mcu/: NXP546XDMA.cpp NXP546XHAL.cpp
    ../bsp/source/platform/cortex-m/: CortexMMCUInstrumentation.cpp
    ../os/: OSWrappers.cpp
  group OS
    ../bsp/SDK/Keil/rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../bsp/SDK/Keil/rtos/freertos_9.0.0/Source/portable/MemMang/: heap_2.c
    ../bsp/SDK/Keil/rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM4F/: port.c fsl_tickless_systick.c
  group Startup
    ../: main.cpp
    ../bsp/SDK/Keil/devices/LPC54608/: system_LPC54608.c
    ../bsp/SDK/Keil/devices/LPC54608/arm/: startup_LPC54608.s
  group board
    ../bsp/board/: board.c board.h clock_config.c clock_config.h fsl_lcd_RK043.c fsl_lcd_RK043.h fsl_spifi_54608_eval_board.c fsl_spifi_54608_eval_board.h fsl_touch_ft5406.c fsl_touch_ft5406.h leds.c leds.h pin_mux.c pin_mux.h
  group driver
    ../bsp/SDK/Keil/devices/LPC54608/drivers/: fsl_adc.c fsl_clock.c fsl_common.c fsl_dma.c fsl_emc.c fsl_flexcomm.c fsl_fmc.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2c_freertos.c fsl_inputmux.c fsl_lcdc.c fsl_power.c fsl_rtc.c fsl_sctimer.c fsl_spi.c fsl_spi_dma.c fsl_spi_freertos.c fsl_spifi.c fsl_spifi_dma.c fsl_usart.c fsl_usart_dma.c fsl_reset.c
  group utilities
    ../bsp/SDK/Keil/devices/LPC54608/utilities/: fsl_debug_console.c
  group Lib
    ../../touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
    ../bsp/SDK/Keil/devices/LPC54608/arm/: keil_lib_power.lib
  group gui
    ../../gui/src/down_screen/: downpresenter.cpp downview.cpp
    ../../gui/src/common/: frontendapplication.cpp
    ../../gui/src/left_screen/: leftpresenter.cpp leftview.cpp
    ../../gui/src/main_screen/: mainpresenter.cpp mainview.cpp
    ../../gui/src/model/: model.cpp
    ../../gui/src/right_screen/: rightpresenter.cpp rightview.cpp
    ../../gui/src/up_screen/: uppresenter.cpp upview.cpp
  group generated
    ../../generated/fonts/src/: applicationfontprovider.cpp font_verdana_10_4bpp.cpp font_verdana_15_4bpp.cpp fontgetters.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_15_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_15_4bpp.cpp
    ../../generated/images/src/: bg_transition_center.cpp bg_transition_down.cpp bg_transition_left.cpp bg_transition_right.cpp bg_transition_up.cpp bitmapdatabase.cpp but12.cpp but21.cpp down_btn.cpp down_btn_pressed.cpp img1.cpp img22.cpp img22_1.cpp img22_2.cpp img3.cpp img4.cpp img5.cpp img6.cpp img6_1.cpp img6_2.cpp img7.cpp img7_1.cpp img7_2.cpp img8.cpp img9.cpp left_btn.cpp left_btn_pressed.cpp ligh.cpp lingsheng.cpp peare_gul.cpp peare_hvid.cpp right_btn.cpp right_btn_pressed.cpp slider1_1.cpp slider1_2.cpp slider_background.cpp slider_background_filled.cpp slider_background_vertical.cpp slider_background_vertical_filled.cpp slider_knob_circle.cpp sw1.cpp sw2_1.cpp sw2_2-5.cpp temp-1.cpp up_btn.cpp up_btn_pressed.cpp
    ../../generated/gui_generated/src/down_screen/: downviewbase.cpp
    ../../generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../../generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../../generated/gui_generated/src/left_screen/: leftviewbase.cpp
    ../../generated/gui_generated/src/main_screen/: mainviewbase.cpp
    ../../generated/gui_generated/src/right_screen/: rightviewbase.cpp
    ../../generated/gui_generated/src/up_screen/: upviewbase.cpp
