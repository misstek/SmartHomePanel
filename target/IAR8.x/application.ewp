# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54608J512 NXP LPC54608J512
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_LPC54608; CPU_LPC54608J512ET180=1; USE_FREERTOS_8; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; FSL_RTOS_FREE_RTOS; USE_BPP=16
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\bsp\board; ..\bsp\SDK\IAR\rtos\freertos_9.0.0\Source\portable\IAR\ARM_CM4F; ..\bsp\SDK\IAR\rtos\freertos_9.0.0\Source\include; $NXP_SDK_PATH$\CMSIS\Include; $NXP_SDK_PATH$\devices; $NXP_SDK_PATH$\devices\LPC54608; $NXP_SDK_PATH$\platform\drivers; $NXP_SDK_PATH$\platform\drivers\common; $NXP_SDK_PATH$\platform\utilities\debug_console; $NXP_SDK_PATH$\devices\LPC54608\utilities; $NXP_SDK_PATH$\devices\LPC54608\drivers; ..\..\generated\images\include; ..\..\generated\fonts\include; ..\..\generated\texts\include; ..\..\generated\gui_generated\include; ..\..\platform\os; ..\..\gui\include; ..\..\touchgfx\framework\include; ..\bsp\include\platform\core\arm\cortex-m\CMSIS; ..\bsp\include\platform; ..\bsp\include\bsp; ..\bsp\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\platform\os; ..
  OBJCOPY.OOCOutputFile: application.srec
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: LPC54608J512_flash.icf
  ILINK.IlinkExtraOptions: --redirect _ZN8touchgfx12TextProvider10initializeEPKt9__va_list=_ZN8touchgfx12TextProvider10initializeEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKc9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKc8_VA_LIST; --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKt9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthLTREhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthLTREhPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthRTLEhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthRTLEhPKt8_VA_LIST
  ILINK.IlinkAdditionalLibs: $NXP_SDK_PATH$\devices\LPC54608\iar\iar_lib_power.a; ..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC54608J512ET180 NXP LPC54608J512ET180
  ICCARM.CCDefines: NDEBUG; CPU_LPC54608; CPU_LPC54608J512ET180=1
  ICCARM.CCIncludePath2: $NXP_SDK_PATH$\CMSIS\Include; $NXP_SDK_PATH$\devices; $NXP_SDK_PATH$\devices\LPC54608; $NXP_SDK_PATH$\platform\drivers; $NXP_SDK_PATH$\platform\drivers\common; ..\..\..\..; ..\; $NXP_SDK_PATH$\platform\utilities\debug_console; $NXP_SDK_PATH$\devices\LPC54608\utilities; $NXP_SDK_PATH$\devices\LPC54608\drivers; ..\..\..\..\generated\images\include; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\texts\include; ..\..\..\..\generated\gui_generated\include; ..\..\..\..\platform\os; ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\board\NXP\LPCXpresso54608\include; ..\..\..\..\..\..\..\touchgfx\board\NXP\LPCXpresso54608\include\bsp
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: spifi_dma_transfer.out
  ILINK.IlinkAdditionalLibs: $NXP_SDK_PATH$\devices\LPC54608\iar\iar_lib_power.a
  group Application/generated/fonts
    ../../generated/fonts/src/: ApplicationFontProvider.cpp
  group Application/generated/gui_generated/common
    ../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/fade_screen
    ../../generated/gui_generated/src/fade_screen/: FadeViewBase.cpp
  group Application/generated/gui_generated/main_screen
    ../../generated/gui_generated/src/main_screen/: MainViewBase.cpp
  group Application/generated/images
    ../../generated/images/src/: BitmapDatabase.cpp Pasted.cpp
  group Application/generated/images/__designer
    ../../generated/images/src/__designer/: Blue_Buttons_Round_Edge_small.cpp Blue_Buttons_Round_Edge_small_pressed.cpp Dark_Textures_gplaypattern.cpp
  group Application/generated/texts
    ../../generated/texts/src/: Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/fade_screen
    ../../gui/src/fade_screen/: FadePresenter.cpp FadeView.cpp
  group Application/gui/main_screen
    ../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group Application/gui/model
    ../../gui/src/model/: Model.cpp
  group Application/main
    ../: main.cpp
  group board
    ../bsp/board/: board.c clock_config.c fsl_lcd_RK043.c fsl_phy.c fsl_spifi_54608_eval_board.c fsl_touch_ft5406.c leds.c pin_mux.c
  group drivers
    $NXP_SDK_PATH$/devices/LPC54608/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dma.c fsl_dma.h fsl_emc.c fsl_emc.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_lcdc.c fsl_lcdc.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_sctimer.c fsl_sctimer.h fsl_spifi.c fsl_spifi.h fsl_spifi_dma.c fsl_spifi_dma.h fsl_usart.c fsl_usart.h
  group freertos
    $NXP_SDK_PATH$/rtos/freertos_9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    $NXP_SDK_PATH$/rtos/freertos_9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    $NXP_SDK_PATH$/rtos/freertos_9.0.0/Source/portable/MemMang/: heap_2.c
  group freertos/portable
    $NXP_SDK_PATH$/rtos/freertos_9.0.0/Source/portable/IAR/ARM_CM4F/: fsl_tickless_generic.h fsl_tickless_systick.c port.c portasm.s portmacro.h
  group startup
    $NXP_SDK_PATH$/devices/LPC54608/iar/: startup_LPC54608.s
    $NXP_SDK_PATH$/devices/LPC54608/: system_LPC54608.c system_LPC54608.h
  group TouchGFXPort/Board
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: FT5336GQQTouchController.cpp
  group TouchGFXPort/MCU
    ../bsp/source/platform/cortex-m/: CortexMMCUInstrumentation.cpp
    ../bsp/source/platform/hal/mcu/: NXP546XDMA.cpp NXP546XHAL.cpp
  group TouchGFXPort/OS
    ../../platform/os/: FreeRTOSConfig.h
    ../os/: OSWrappers.cpp
  group utilities
    $NXP_SDK_PATH$/devices/LPC54608/utilities/: fsl_debug_console.c fsl_debug_console.h
